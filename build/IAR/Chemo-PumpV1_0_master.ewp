# IAR project Chemo-PumpV1_0_master.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152VE ST STM32L152VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32L152xCA; USE_HAL_DRIVER; DEBUG; USE_FULL_ASSERT; SSZ_TARGET_MACHINE
  ICCARM.CCIncludePath2: ..\..\config; ..\..\source; ..\..\source\common; ..\..\source\ui_common; ..\..\source\ui_common\resource; ..\..\source\ui_common\widget; ..\..\source\app; ..\..\source\app\screens; ..\..\source\middleware; ..\..\source\middleware\kernel; ..\..\source\driver; ..\..\lib\ssz_micro_sys\bsp; ..\..\lib\ssz_micro_sys\include; ..\..\lib\ssz_ui\include; ..\..\lib\ssz_ui\source; ..\..\lib\ssz_ui\include\view; ..\..\lib\ssz_ui\include\view\widget; ..\..\bsp\bsp_machine\Inc; ..\..\bsp\bsp_machine\Drivers\CMSIS\Include; ..\..\bsp\bsp_machine\Drivers\CMSIS\Device\ST\STM32L1xx\Include; ..\..\bsp\bsp_machine\Drivers\STM32L1xx_HAL_Driver\Inc; ..\..\lib\emwin; ..\..\lib\emwin\Config; ..\..\lib\emwin\inc; ..\..\lib\emwin\Lib; ..\..\lib\emwin\OS; ..\..\bsp\bsp_machine\Drivers\CMSIS\Device\ST\STM32L1xx\Include; ..\..\ert_drv\ert; ..\..\matlib; ..\..\matlib\Src; ..\..\matlib\Src\UIDispDrv_ert_rtw; ..\..\matlib\Include; ..\..\matlib\Include\untitled_grt_rtw
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: master.bin
  ILINK.IlinkOutputFile: Chemo-PumpV1_0_master.out
  ILINK.IlinkIcfFile: Chemo-PumpV1_0_master.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152xC ST STM32L152xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32L152xC; USE_HAL_DRIVER; NDEBUG; SSZ_TARGET_MACHINE
  ICCARM.CCIncludePath2: ..\..\config; ..\..\source; ..\..\source\common; ..\..\source\ui_common; ..\..\source\ui_common\resource; ..\..\source\ui_common\widget; ..\..\source\app; ..\..\source\app\screens; ..\..\source\middleware; ..\..\source\middleware\kernel; ..\..\source\driver; ..\..\lib\ssz_micro_sys\bsp; ..\..\lib\ssz_micro_sys\include; ..\..\lib\ssz_ui\include; ..\..\lib\ssz_ui\source; ..\..\lib\ssz_ui\include\view; ..\..\lib\ssz_ui\include\view\widget; ..\..\bsp\bsp_machine\Inc; ..\..\bsp\bsp_machine\Drivers\CMSIS\Include; ..\..\bsp\bsp_machine\Drivers\CMSIS\Device\ST\STM32L1xx\Include; ..\..\bsp\bsp_machine\Drivers\STM32L1xx_HAL_Driver\Inc
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: Chemo-PumpV1_0_master.bin
configuration Test (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152xC ST STM32L152xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32L152xC; USE_HAL_DRIVER; DEBUG; USE_FULL_ASSERT; TEST; SSZ_TARGET_MACHINE
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: Chemo-PumpV1_0_master.bin
  group bsp_machine/Drivers/CMSIS/Device/ST/STM32L1xx/Include
    ../../bsp/bsp_machine/Drivers/CMSIS/Device/ST/STM32L1xx/Include/: stm32l152xca.h stm32l1xx.h system_stm32l1xx.h
  group bsp_machine/Drivers/CMSIS/Include
    ../../bsp/bsp_machine/Drivers/CMSIS/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
  group bsp_machine/Drivers/STM32L1xx_HAL_Driver/Inc
    ../../bsp/bsp_machine/Drivers/STM32L1xx_HAL_Driver/Inc/: stm32l1xx_hal.h stm32l1xx_hal_adc.h stm32l1xx_hal_adc_ex.h stm32l1xx_hal_cortex.h stm32l1xx_hal_crc.h stm32l1xx_hal_def.h stm32l1xx_hal_dma.h stm32l1xx_hal_flash.h stm32l1xx_hal_flash_ex.h stm32l1xx_hal_flash_ramfunc.h stm32l1xx_hal_gpio.h stm32l1xx_hal_gpio_ex.h stm32l1xx_hal_pwr.h stm32l1xx_hal_pwr_ex.h stm32l1xx_hal_rcc.h stm32l1xx_hal_rcc_ex.h stm32l1xx_hal_spi.h stm32l1xx_hal_tim.h stm32l1xx_hal_tim_ex.h stm32l1xx_hal_uart.h
  group bsp_machine/Drivers/STM32L1xx_HAL_Driver/Inc/Legacy
    ../../bsp/bsp_machine/Drivers/STM32L1xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
  group bsp_machine/Drivers/STM32L1xx_HAL_Driver/Src
    ../../bsp/bsp_machine/Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_crc.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c
  group bsp_machine/EWARM
    ../../bsp/bsp_machine/EWARM/: startup_stm32l152xca.s stm32l152xc_flash.icf stm32l152xc_sram.icf
  group bsp_machine/Inc
    ../../bsp/bsp_machine/Inc/: adc.h crc.h gpio.h main.h spi.h stm32l1xx_hal_conf.h stm32l1xx_it.h tim.h usart.h
  group bsp_machine/Src
    ../../bsp/bsp_machine/Src/: adc.c crc.c gpio.c main.c spi.c stm32l1xx_hal_msp.c stm32l1xx_it.c system_stm32l1xx.c tim.c usart.c
  group config
    ../../config/: alarm_config.h clock.c com_config.h config.c config.h data_config.h event_config.h key_config.h msg_config.h read.c record_log_config.h screen_config.h ssz_config.cpp ssz_config.h ssz_ui_config.c ssz_ui_config.h timer_config.h write.c
  group emwin/config
    ../../lib/emwin/OS/: GUI_X.c
    ../../lib/emwin/Config/: GUIConf.c GUIConf.h GUIDRV_Template.c GUIDRV_Template.h LCDConf_FlexColor_Template.c LCDConf_FlexColor_Template.h
    ../../lib/ssz_ui/source/: ui_utility.c
    ../../lib/ssz_ui/include/: ui_utility.h
  group emwin/lib
    ../../lib/emwin/Lib/: STemWin_CM3_wc32.a
  group ert_drv/ert
    ../../ert_drv/ert/: ert_channelsADC_Major.c ert_channelsADC_Major.h ert_getKeyVector.c ert_getKeyVector.h ert_RTC.c ert_RTC.h
  group matlib
    ../../matlib/: rt_nonfinite.c rt_nonfinite.h rtGetInf.c rtGetInf.h rtGetNaN.c rtGetNaN.h rtwtypes.h test2_SysIntegration.c test2_SysIntegration.h test2_SysIntegration_data.c test2_SysIntegration_private.h test2_SysIntegration_types.h zero_crossing_types.h
  group matlib/inc
    ../../matlib/Include/: alarmIt.h channelsADC.h chkBleConnection.h chkDoseEnds.h dataErase.h dataRead.h dataWrite.h dispUpdate.h doseTimerStart.h encoderRead.h forceMotorStop.h getBleData.h getKeyVector.h getSerialData.h ioCtrl.h lcdCtrl.h lpCtrl.h motorRunInSpeedMode.h motorServoCtrl.h MsgBody4TaskStat.h pwmTransducer.h readRTChip.h recordErase.h recordRead.h recordWrite.h sendBleData.h sendSerialData.h servoStateInquiry.h uiDisp.h writeRTChip.h
  group matlib/src
    ../../matlib/Src/: alarmIt.c channelsADC.c chkBleConnection.c chkDoseEnds.c dataErase.c dataRead.c dataWrite.c dispUpdate.c doseTimerStart.c encoderRead.c forceMotorStop.c getBleData.c getKeyVector.c getSerialData.c ioCtrl.c lcdCtrl.c lpCtrl.c motorRunInSpeedMode.c motorServoCtrl.c pwmTransducer.c readRTChip.c recordErase.c recordRead.c recordWrite.c sendBleData.c sendSerialData.c servoStateInquiry.c uiDisp.c writeRTChip.c
  group source
    ../../source/: do_before_main_loop.cpp do_before_main_loop.h init.cpp init.h main_run.c main_run.h run_test_after_main.cpp version.c version.h
  group source/app
    ../../source/app/: app_route.cpp app_route.h
  group source/app/screens
    ../../source/app/screens/: app_scr_class1.c app_scr_class1.h app_scr_class10.c app_scr_class10.h app_scr_class11.c app_scr_class11.h app_scr_class12.c app_scr_class12.h app_scr_class13.c app_scr_class13.h app_scr_class18.c app_scr_class18.h app_scr_class2.c app_scr_class2.h app_scr_class20.c app_scr_class20.h app_scr_class3.c app_scr_class3.h app_scr_class4.c app_scr_class4.h app_scr_class5.c app_scr_class5.h app_scr_class6.c app_scr_class6.h app_scr_class8.c app_scr_class8.h app_scr_class9.c app_scr_class9.h app_scr_error_22000.c app_scr_error_22000.h app_scr_exhaust_11200.c app_scr_exhaust_11200.h app_scr_exhaust_pause.c app_scr_exhaust_pause.h app_scr_exhaust_start.c app_scr_exhaust_start.h app_scr_exhaust_tip_11100.c app_scr_exhaust_tip_11100.h app_scr_histroy_15100.c app_scr_histroy_15100.h app_scr_home_02000.c app_scr_home_02000.h app_scr_infusion_speed_12400.c app_scr_infusion_speed_12400.h app_scr_init_screen.c app_scr_init_screen.h app_scr_lock_error_34000.c app_scr_lock_error_34000.h app_scr_lock_method_33000.c app_scr_lock_method_33000.h app_scr_lock_tip_32000.c app_scr_lock_tip_32000.h app_scr_logo_01000.c app_scr_logo_01000.h app_scr_main_menu_11000.c app_scr_main_menu_11000.h app_scr_set_14100.c app_scr_set_14100.h app_scr_set_date_14120.c app_scr_set_date_14120.h app_scr_set_dose_12300.c app_scr_set_dose_12300.h app_scr_set_time_14110.c app_scr_set_time_14110.h app_scr_set_year_14130.c app_scr_set_year_14130.h app_scr_shutdown_41000.c app_scr_shutdown_41000.h app_scr_stop_infusion_13100.c app_scr_stop_infusion_13100.h app_scr_test_current_max.c app_scr_test_current_max.h app_scr_test_current_min.c app_scr_test_current_min.h app_scr_test_gain.c app_scr_test_gain.h app_scr_test_minus_offset.c app_scr_test_minus_offset.h app_scr_test_plus_offset.c app_scr_test_plus_offset.h app_scr_version_14140.c app_scr_version_14140.h
  group source/common
    ../../source/common/: common.c common.h dev_def.c dev_def.h
  group source/driver
    ../../source/driver/: drv_com.c drv_com.h drv_infusion_motor.c drv_infusion_motor.h drv_interrupt.c drv_interrupt.h drv_isd2360.c drv_isd2360.h drv_key.c drv_key.h drv_lowpower.c drv_lowpower.h drv_oled.c drv_oled.h drv_rtc.c drv_rtc.h drv_sst25_flash.c drv_sst25_flash.h drv_stf_motor.c drv_stf_motor.h
  group source/middleware
    ../../source/middleware/: alarm.c alarm.h alarm_play.c alarm_play.h com.c com.h data.c data.h display.c display.h infusion_motor.c infusion_motor.h key.c key.h led.c led.h mid_adc.c mid_adc.h mid_common.c mid_common.h mid_rtc.c mid_rtc.h param.c param.h param_internal.h pill_box_install_detect.c pill_box_install_detect.h pressure_bubble_sensor.c pressure_bubble_sensor.h record_log.c record_log.h record_log_text.c record_log_text.h simple_alloc.c simple_alloc.h sys_power.c sys_power.h three_valve_motor.c three_valve_motor.h vibrater_motor.c vibrater_motor.h voice.c voice.h
  group source/middleware/kernel
    ../../source/middleware/kernel/: cpu_usage.c cpu_usage.h dtimer.c dtimer.h event.c event.h msg.c msg.h stop_watch.c stop_watch.h timer.c timer.h
  group source/ui_common
    ../../source/ui_common/: ui_common.cpp ui_common.h ui_define.h ui_theme_define.h
  group source/ui_common/resource
    ../../source/ui_common/resource/: font_data.c font_data.h image_data.c image_data.h string_data.c string_data.h
  group source/ui_common/resource/font
    ../../source/ui_common/resource/font/: dengxian_regular_14.c heiti_regular_20.c heiti_regular_60.c heiti_regular_88.c
  group source/ui_common/resource/image
    ../../resource/image/: AC.c AutoCycle.c AutoCycle_breaktime.c AutoCycle_effectivetime.c AutoCycle_rate.c AutoCycle_worktime.c battery_AC.c battery_empty.c battery_full.c battery_no.c battery_one.c battery_three.c battery_two.c error.c exhaust.c exhaust_pause.c exhaust_run.c flush_max_dose_selected.c flush_max_dose_unselected.c history_log.c info_select.c info_unselect.c infusion_pause.c infusion_run.c infusion_stop.c left_arrow.c lock.c log_alarm.c log_opeartion.c logo.c mode_selected.c mode_unselected.c mute.c mute_small.c new_task.c passwordchange.c passwordnotchange.c PCA.c PCA_first.c PCA_regular.c PCA_time.c peak_set_select.c peak_set_unselect.c poweroffcheck.c right_arrow.c select_1.c select_2.c selected_pointer.c set_arrow.c setmenu_passwordn.c setmenu_time.c setmenu_unit.c setmenu_version.c sound_pause.c stop_infusion.c system_setting.c time_select.c time_unselect.c unlockfail.c unselected_pointer.c warning.c warning_common.c
  group source/ui_common/widget
    ../../source/ui_common/widget/: widget_image.c widget_image.h widget_text.c widget_text.h
  group ssz_micro_sys/bsp/simulator
    ../../lib/ssz_micro_sys/bsp/simulator/: ssz_simulator_bsp.c ssz_simulator_dev_def.h ssz_simulator_gpio_bsp.h
  group ssz_micro_sys/bsp/stm32_hal
    ../../lib/ssz_micro_sys/bsp/stm32_hal/: ssz_stm32_hal_bsp.c ssz_stm32_hal_gpio_bsp.h
  group ssz_micro_sys/include
    ../../lib/ssz_micro_sys/include/: ssz_algorithm.h ssz_block_file.h ssz_common.h ssz_def.h ssz_deque.h ssz_errorcode.h ssz_file.h ssz_gpio.h ssz_i2c.h ssz_io.h ssz_list.h ssz_locale.h ssz_map.h ssz_nvram.h ssz_precision_tick_time.h ssz_queue.h ssz_record.h ssz_safe_queue.h ssz_sim_i2c.h ssz_spi.h ssz_stack.h ssz_stop_watch.h ssz_str_utility.h ssz_tick_time.h ssz_time.h ssz_time_utility.h ssz_timer.h ssz_uart.h ssz_utility.h ssz_vector.h
  group ssz_micro_sys/source
    ../../lib/ssz_micro_sys/source/: ssz_algorithm.c ssz_block_file.c ssz_common.c ssz_deque.c ssz_file.c ssz_gpio.c ssz_i2c.c ssz_list.c ssz_locale.c ssz_map.c ssz_nvram.c ssz_precision_tick_time.c ssz_queue.c ssz_record.c ssz_safe_queue.c ssz_sim_i2c.c ssz_spi.c ssz_stack.c ssz_stop_watch.c ssz_str_utility.c ssz_tick_time.c ssz_time.c ssz_time_utility.c ssz_timer.c ssz_uart.c ssz_utility.c ssz_vector.c
  group ssz_ui/include
    ../../lib/ssz_ui/include/: ui.h
  group ssz_ui/source
    ../../lib/ssz_ui/source/: ui_draw.c
  group test
    ../../test/: app_sleep_suite_def.h data_suite_def.h drv_lowpower_suite_def.h drv_oled_suite_def.h drv_rtc_suite_def.h drv_sst25_flash_suite_def.h greatest.c greatest.h greatest_config.h hardware_ljl_suite_def.h record_log_suite_def.h run_all_test_suite.c run_test.c ssz_algorithm_suite_def.h ssz_str_utility_suite_def.h ssz_time_suite_def.h ssz_time_utility_suite_def.h test_app_sleep.cpp test_data.c test_drv_lowpower.cpp test_drv_oled.c test_drv_rtc.c test_drv_sst25_flash.c test_hardware_ljl.c test_record_log.c test_ssz_algorithm.c test_ssz_str_utility.c test_ssz_time.c test_ssz_time_utility.c test_ui.c test_ui_view.cpp ui_suite_def.h ui_view_suite_def.h
